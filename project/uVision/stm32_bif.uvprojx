# Keil uVision project stm32_bif.uvprojx, settings and files
target release (ARM-ADS)
  device: STM32F215ZETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_m01_pc +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output .\Output\stm32_m01_pc.bin .\Output\stm32_m01_pc.axf
  c flags: Optim=4 wLevel=2
  c define: STM32F2XX, USE_STDPERIPH_DRIVER
  c include: ..\..\inc;..\..\lib\STM32F2xx_StdPeriph_Driver\inc;D:\Keil_v5\ARM\Pack\ARM\CMSIS\4.5.0\CMSIS\Include;D:\Keil_v5\ARM\ARMCC\include;..\..\boot_driver\inc
  memory RVCT4: ROM 0x8005000 size 0x7b000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../src/CMSIS/uVision/: startup_stm32f2xx.s system_stm32f2xx.c
  group Driver
    ../../src/: driver_bifgpio.c driver_led.c driver_timer.c driver_usart.c
  group STM32F2xx_StdPeriph_Driver
    ../../lib/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_spi.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_flash.c stm32f2xx_dma.c
  group User
    ../../src/: bif_addr_io.c bif_driver.c bif_protocol.c bif_search.c optiga.c optiga_auth.c optiga_crypto.c optiga_curve.c optiga_host.c optiga_nvm.c optiga_async.c display_utils.c
  group crypto
    ../../lib/: IKV_Crypto.lib
  group igs
    ../../src/: main.c igs_timer.c igs_init.c igs_task.c igs_ikv.c igs_gpio.c igs_spi.c igs_protocol.c igs_pulseDevice.c igs_dispenser.c igs_acceptor.c igs_counter.c igs_queue.c igs_uart.c igs_pwm.c igs_can.c igs_marquee.c igs_adc.c igs_fan.c igs_malloc.c igs_scanKey.c igs_marquee_driver.c igs_command.c igs_handler.c
  group boot_driver
    ../../boot_driver/: flash_if.c IGS_STM32_IAP_APP.c
target debug (ARM-ADS)
  device: STM32F215ZETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.0.0
  cpu: as above
  output: stm32_m01_pc +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F2XX, USE_STDPERIPH_DRIVER, DEBUG
  c include: ..\..\inc;..\..\lib\STM32F2xx_StdPeriph_Driver\inc;D:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include;D:\Keil_v5\ARM\ARMCC\include;..\..\boot_driver\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
