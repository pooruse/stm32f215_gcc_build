# IAR project Project.ewp, settings and files
configuration STM322xG_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX
  ICCARM.CCIncludePath2: $EW_DIR$\arm\inc\c; $EW_DIR$\arm\CMSIS\Include; ..\..\inc; ..\..\lib\STM32F2xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: stm32f2xx_flash.icf
  group CMSIS
    ../../src/CMSIS/IAR/: startup_stm32f2xx.s system_stm32f2xx.c
  group crypto
    ../../lib/: IKV_Crypto.a
  group Driver
    ../../src/: driver_bifgpio.c driver_led.c driver_timer.c driver_usart.c
  group STM32F2xx_StdPeriph_Driver
    ../../lib/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_tim.c stm32f2xx_usart.c
  group User
    ../../src/: bif_addr_io.c bif_driver.c bif_protocol.c bif_search.c display_utils.c main.c optiga.c optiga_async.c optiga_auth.c optiga_crypto.c optiga_curve.c optiga_host.c optiga_nvm.c
