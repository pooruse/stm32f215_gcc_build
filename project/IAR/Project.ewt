<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>STM322xG_EVAL</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\..\..\src\CMSIS\IAR\startup_stm32f2xx.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\CMSIS\IAR\system_stm32f2xx.c</name>
    </file>
  </group>
  <group>
    <name>crypto</name>
    <file>
      <name>$PROJ_DIR$\..\..\lib\IKV_Crypto.a</name>
    </file>
  </group>
  <group>
    <name>Driver</name>
    <file>
      <name>$PROJ_DIR$\..\..\src\driver_bifgpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\driver_led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\driver_timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\driver_usart.c</name>
    </file>
  </group>
  <group>
    <name>STM32F2xx_StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\..\lib\STM32F2xx_StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\lib\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\lib\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\lib\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\lib\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_usart.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\..\..\src\bif_addr_io.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\bif_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\bif_protocol.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\bif_search.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\display_utils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\optiga.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\optiga_async.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\optiga_auth.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\optiga_crypto.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\optiga_curve.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\optiga_host.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\optiga_nvm.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\stm32f2xx_flash.icf</name>
  </file>
</project>


